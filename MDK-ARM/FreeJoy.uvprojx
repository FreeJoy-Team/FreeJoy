# Keil uVision project FreeJoy.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreeJoy +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Drivers\CMSIS\CM3\CoreSupport;..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\Drivers\STM32_USB-FS-Device_Driver\inc;../application/Inc;..\utils;../;..\SEGGER\SEGGER;..\SEGGER\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xc800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Application/User
    ../application/Src/: main.c stm32f10x_it.c periphery.c analog.c config.c buttons.c shift_registers.c encoders.c axis_to_buttons.c leds.c ads1115.c as5600.c mcp320x.c tle5011.c mlx90393.c usb_endp.c usb_desc.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c spi.c i2c.c
    ../application/Inc/: common_types.h common_defines.h main.h
  group Bootloader
    ../bootloader/Src/: main.c periphery.c stm32f10x_it.c usb_desc.c usb_endp.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c
    ../bootloader/Inc/: stm32f10x_conf.h
  group Utils
    ../utils/: crc16.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_i2c.c
    ../application/Inc/: stm32f10x_conf.h
  group USB-FS-Device_Driver
    ../Drivers/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SEGGER
    ../SEGGER/SEGGER/: SEGGER_SYSVIEW.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../SEGGER/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
    ../SEGGER/Config/: SEGGER_SYSVIEW_Conf.h SEGGER_RTT_Conf.h
target Bootloader (6110000::V6.11::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, STM32F103xB, STM32F10X_MD
  c include: ..\Drivers\CMSIS\CM3\CoreSupport;..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Drivers\STM32F10x_StdPeriph_Driver\inc;../bootloader/Inc;../;..\utils;..\Drivers\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
