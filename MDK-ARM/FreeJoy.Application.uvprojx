# Keil uVision project FreeJoy.Application.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeJoy
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER __MICROLIB
  c include: ../;../Drivers/CMSIS/CM3/CoreSupport;../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x;../Drivers/STM32F10x_StdPeriph_Driver/inc;../Drivers/STM32_USB-FS-Device_Driver/inc;../SEGGER/Config;../SEGGER/SEGGER;../application/Inc;../utils;C:/Keil_v5/ARM/CMSIS/Include
  asm include: :/Keil_v5/ARM/CMSIS/Include
  library: MicroLIB
  memory RVCT4: RAM 0x8000000 size 0x10000
  memory RVCT9: ROM 0x20000000 size 0x5000
  scatter file: ./FreeJoy.Application.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group Application/MDK-ARM
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Application/User
    ../application/Src/: main.c stm32f10x_it.c periphery.c analog.c config.c buttons.c shift_registers.c encoders.c axis_to_buttons.c leds.c ads1115.c as5600.c mcp320x.c tle5011.c mlx90393.c usb_endp.c usb_desc.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c spi.c i2c.c
    ../application/Inc/: common_types.h common_defines.h main.h
  group Utils
    ../utils/: crc16.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_i2c.c
    ../application/Inc/: stm32f10x_conf.h
  group USB-FS-Device_Driver
    ../Drivers/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SEGGER
    ../SEGGER/SEGGER/: SEGGER_SYSVIEW.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../SEGGER/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
    ../SEGGER/Config/: SEGGER_SYSVIEW_Conf.h SEGGER_RTT_Conf.h
